# Keil uVision project Project.uvprojx, settings and files
target STM32F4-DISCO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WP0001 +hex
  AfterMake: C:\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin --output=..\objects\audiob.003 ..\objects\WP0001.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F4_DISCO,USE_FULL_LL_DRIVER,HW_VER_512KB, STM32F4,  HW_VER_22, DBG_TST_X
  c include: ..\Include;..\Libraries\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\Drivers\STM32F4xx_HAL_Driver\Inc;..\Libraries\Drivers\BSP\STM32F4-Discovery;..\Libraries\STM32_USB_Host_Library\Class\MSC\Inc;..\Libraries\STM32_USB_Host_Library\Core\Inc;..\Libraries\FatFs\src;..\vssrc;..\EventQueue;..\Libraries\ILI9341;..\Libraries\ili9488;..\USB_DEVICE\App;..\USB_DEVICE\Target;..\Middlewares\ST\STM32_USB_Device_Library;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\Middlewares\ST\STM32_USB_Device_Library\Core\Src
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\Objects\WP0001.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Source/: system_stm32f4xx.c
  group Drivers/BSP/STM32F4-Discovery
    ../Libraries/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio.c stm32f4_discovery_sd.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../Libraries/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_i2s.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rng.c
    ../../FTQ-99Sx/FTQ-99Sx/Libraries/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_dma.c stm32f4xx_ll_usart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_tim.c
  group Middlewares/STM32_USBH_Library/Core
    ../Libraries/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../Libraries/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/FatFs/Core
    ../Libraries/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../Libraries/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FatFs/Drivers
    ../Source/: usbh_diskio_dma.c sd_diskio.c
  group Application/User
    ../Source/: main.c stm32f4xx_it.c usbh_conf.c waveplayer.c uart.c Wireless.c VisualStateMachine.c Device.c SystemTimer.c Display.c ADC.c TimeCode.c Buttons.c USBHostMain.c flash_if.c sht3x.c GlobalPositioning.c
    ../: ChangeLog.txt Bugs.txt TO ADD
  group vssrc
    ../vssrc/: System1.c System1Data.c System1SEMLibB.c
  group EventQueue
    ../EventQueue/: simpleEventHandler.c
  group IL9341 LCD
    ../Libraries/ILI9341/: ILI9341_GFX.c ILI9341_STM32_Driver.c 2Wires 15x24.c AudioPlayer 16x24 32b.c Batter 14x24 OK.c Channel status 15x24 32b  OK.c Main 19x48 OK.c Module Stat 11x24 32b.c Time code  18x24 32b.c Time Hum Temp Font.c tm_stm32f4_fonts.c Wireless 22x24.c font24.c
    ./: Menlo 32h.c WE 20 x 23.c Font Small 10x20.c Icon GPS Err.c Arial 14.c Font 12x16.c FONT 15X16.c
  group ILI9488
    ../Libraries/ili9488/: ili9488.c lcd_io_spi.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0
